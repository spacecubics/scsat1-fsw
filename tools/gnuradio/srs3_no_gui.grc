options:
  parameters:
    generate_options: no_gui
    id: no_gui_srs3_flow
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: SRS-3 test flow without GUI
  states: {}

blocks:
- name: frame_size
  id: variable
  parameters:
    value: satlab.frame_size(rx_size, rx_crc, rx_rs, rx_cc, rx_id , rx_decrypt, rx_auth)
  states: {}
- name: rx_auth
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: rx_cc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: rx_chan_samp_rate
  id: variable
  parameters:
    value: rx_sps*rx_rate
  states: {}
- name: rx_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: rx_decrypt
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 2278.6e6
  states: {}
- name: rx_id
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_key
  id: variable
  parameters:
    value: '"0000000000000000000000000000000000000000000000000000000000000000"'
  states: {}
- name: rx_rand
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: rx_rate
  id: variable
  parameters:
    value: rx_rate_kbps*1000
  states: {}
- name: rx_rate_kbps
  id: variable
  parameters:
    value: '512'
  states: {}
- name: rx_rs
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: rx_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: rx_sps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.56e6
  states: {}
- name: tx_auth
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: tx_bt
  id: variable
  parameters:
    value: '0.90'
  states: {}
- name: tx_cc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: tx_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: tx_encrypt
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 2105.35e6
  states: {}
- name: tx_id
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_key
  id: variable
  parameters:
    value: '"0000000000000000000000000000000000000000000000000000000000000000"'
  states: {}
- name: tx_preamble
  id: variable
  parameters:
    value: '8'
  states: {}
- name: tx_rand
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: tx_rate
  id: variable
  parameters:
    value: tx_rate_kbps * 1000
  states: {}
- name: tx_rate_kbps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: tx_rs
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: tx_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: int((samp_rate / tx_rate) * ((satlab.frame_size(tx_size, tx_crc, tx_rs, tx_cc, tx_id, tx_encrypt, tx_auth, True, True) + tx_preamble) * 8 + 10))
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(tx_freq)
    len_tag_key: packet_len
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '262144'
    filter_source: '''Auto'''
    frequency: int(rx_freq)
    gain1: '''manual'''
    manual_gain1: '20'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import satlab
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    oversample: '0'
    rf_freq: tx_freq
    samp_rate: samp_rate
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    ch_align: 'False'
    channel_mode: '0'
    oversample: '0'
    rf_freq: rx_freq
    samp_rate: samp_rate
  states: {}
- name: network_socket_pdu_0_1
  id: network_socket_pdu
  parameters:
    mtu: '1500'
    port: '52002'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_0_1_0
  id: network_socket_pdu
  parameters:
    host: udp_addr
    mtu: '1500'
    port: '52004'
    type: UDP_CLIENT
  states: {}
- name: satlab_srs3_rx_0
  id: satlab_srs3_rx
  parameters:
    auth: rx_auth
    cc: rx_cc
    crc: rx_crc
    decrypt: rx_decrypt
    idnum: rx_id
    key: bytes.fromhex(rx_key) if len(rx_key) == 64 else '\x00' * 32
    rand: rx_rand
    rate: rx_rate
    rs: rx_rs
    samp_rate: samp_rate
    size: rx_size
  states: {}
- name: satlab_srs3_tx_0
  id: satlab_srs3_tx
  parameters:
    auth: tx_auth
    bt: tx_bt
    cc: tx_cc
    crc: tx_crc
    encrypt: tx_encrypt
    idleframes: '0'
    idnum: tx_id
    key: bytes.fromhex(tx_key) if len(tx_key) == 64 else '\x00' * 32
    max_in_flight: '100'
    preamble: tx_preamble
    rand: tx_rand
    rate: tx_rate
    rs: tx_rs
    samp_rate: samp_rate
    size: tx_size
  states: {}
- name: udp_addr
  id: parameter
  parameters:
    label: host name where telemetry send to
    short_id: d
    type: str
    value: '''localhost'''
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: tx_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '40'
    len_tag_name: packet_len
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(rx_freq, -samp_rate/2)
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '15'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: verbose
  id: parameter
  parameters:
    label: Enable Noisy Output
    short_id: v
    type: intx
    value: '0'
  states: {}

connections:
- [iio_pluto_source_0, '0', satlab_srs3_rx_0, '0']
- [limesdr_source_0, '0', satlab_srs3_rx_0, '0']
- [network_socket_pdu_0_1, pdus, satlab_srs3_tx_0, csp_in]
- [satlab_srs3_rx_0, csp_out, blocks_message_debug_0, print]
- [satlab_srs3_rx_0, csp_out, network_socket_pdu_0_1, pdus]
- [satlab_srs3_rx_0, csp_out, network_socket_pdu_0_1_0, pdus]
- [satlab_srs3_tx_0, '0', iio_pluto_sink_0, '0']
- [satlab_srs3_tx_0, '0', limesdr_sink_0, '0']
- [satlab_srs3_tx_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', satlab_srs3_rx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-352-g6efdc9d8
